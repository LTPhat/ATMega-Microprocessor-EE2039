; Dùng chương trình con Delay1s viết chương trình chớp/tắt 1 LED gắn vào PA0.
.ORG 0
		RJMP MAIN
		.ORG $40
MAIN:	
		LDI R16,HIGH(RAMEND)
		OUT SPH,R16
		LDI R16,LOW(RAMEND)
		OUT SPL,R16
		LDI R16,$01
		OUT DDRA,R16 ;PA0 LA NGO RA

START:
		CBI PORTA,0
		RCALL DELAY_1S
		SBI PORTA,0
		RCALL DELAY_1S
		RJMP START

DELAY_1S:
		LDI R22,32
LP3:	LDI R21,250
LP2:	LDI R20,250
LP1:	NOP
		DEC R20
		BRNE LP1
		DEC R21
		BRNE LP2
		DEC R22
		BRNE LP3
		RET
