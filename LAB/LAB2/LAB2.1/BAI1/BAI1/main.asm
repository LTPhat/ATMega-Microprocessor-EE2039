; N = 64 -> Tclkto = 8uS -> n = 125
.EQU	P_OUT = 0
.ORG	0
RJMP	MAIN
.ORG	0x40
MAIN:	
	LDI		R16, HIGH(RAMEND)
	OUT		SPH, R16
	LDI		R16, LOW(RAMEND)
	OUT		SPL, R16
	LDI		R16, (1<<P_OUT)
	OUT		DDRA, R16		; PA0 = output
	LDI		R17, 0x00		; NOR mode, timer stop
	OUT		TCCR0B, R17
START:	
	RCALL	DELAY_1MS
	IN		R17, PORTA		
	EOR		R17, R16
	OUT		PORTA, R17
	RJMP	START
DELAY_1MS:
	LDI		R17, -125
	OUT		TCNT0, R17
	LDI		R17, 0x03		; N = 64
	OUT		TCCR0B, R17
WAIT:
	IN		R17, TIFR0
	SBRS	R17, TOV0
	RJMP	WAIT
	OUT		TIFR0, R17
	LDI		R17, 0x00
	OUT		TCCR0B, R17
	RET